# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6210000::V6.21::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: DEBUG, RT_USING_LIBC, __RTTHREAD__, CPU_MCXN947VDF_cm33_core0, RT_USING_ARMLIBC, CONFIG_USB_HS, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\drivers\include;..\libraries\drivers\config;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\nboot;board\MCUX_Config\board;board;..\libraries\drivers;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\usb\cherryusb;..\..\..\..\..\components\drivers\usb\cherryusb\class\adb;..\..\..\..\..\components\drivers\usb\cherryusb\class\serial;packages\nxp-mcx-cmsis-latest\Core\Include;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\display;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\port\chipidea;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\clock_time;.;..\..\..\..\..\components\drivers\usb\cherryusb\osal;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\mem_interface;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\..\..\libcpu\arm\common;applications;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\utest;..\..\..\..\..\components\libc\posix\ipc;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\flash;..\..\..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\..\..\components\drivers\usb\cherryusb\class\hid;..\..\..\..\..\components\drivers\audio;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\libc\compilers\common\extension;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\runbootloader;..\..\..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\..\..\components\drivers\usb\cherryusb\class\cdc;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\wifi;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\usb\cherryusb\class\dfu;packages\nxp-mcx-series-latest\MCXN947;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\hub;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\xbox;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\usb\cherryusb\common;..\..\..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\..\..\include;..\..\..\..\..\components\drivers\usb\cherryusb\core;packages\nxp-mcx-series-latest\MCXN947\drivers
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: main.c mic_resample.c usb_adc_mic.c
  group CPU
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../../../components/drivers/clock_time/: clock_boottime.c clock_hrtimer.c clock_time_core.c clock_timer.c
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_port.c
    ../libraries/drivers/: drv_mic.c drv_pin.c drv_timer.c drv_uart.c mic_algo.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_std.c rt_vsscanf.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    packages/nxp-mcx-series-latest/MCXN947/drivers/: fsl_cache.c fsl_cache_lpcac.c fsl_cdog.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_dac.c fsl_dac14.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_enet.c fsl_erm.c fsl_evtg.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_smartdma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexspi.c fsl_flexspi_edma.c fsl_freqme.c fsl_gdet.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_intm.c fsl_irtc.c fsl_itrc.c fsl_lpadc.c fsl_lpcmp.c fsl_lpflexcomm.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_mrt.c fsl_opamp.c fsl_ostimer.c fsl_pdm.c fsl_pdm_edma.c fsl_pint.c fsl_plu.c fsl_power.c fsl_powerquad_basic.c fsl_powerquad_data.c fsl_powerquad_filter.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_transform.c fsl_puf_v3.c fsl_pwm.c fsl_qdc.c fsl_reset.c fsl_sai.c fsl_sai_edma.c fsl_sctimer.c fsl_sema42.c fsl_sinc.c fsl_smartcard_emvsim.c fsl_smartcard_phy_emvsim.c fsl_smartdma.c fsl_smartdma_mcxn.c fsl_smartdma_rt500.c fsl_spc.c fsl_syspm.c fsl_tdet.c fsl_trdc.c fsl_tsi_v6.c fsl_usdhc.c fsl_utick.c fsl_vbat.c fsl_vref.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    packages/nxp-mcx-series-latest/MCXN947/: system_MCXN947_cm33_core0.c
  group UsbStack
    ../../../../../components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../../../components/drivers/usb/cherryusb/port/chipidea/: usb_dc_chipidea.c
    ../../../../../components/drivers/usb/cherryusb/port/nxp/: usb_glue_mcx.c
    ../../../../../components/drivers/usb/cherryusb/class/audio/: usbd_audio.c
    ../../../../../components/drivers/usb/cherryusb/platform/rtthread/: rt_usb_msh.c rt_usb_check.c
  group Utilities
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ulog/backend/: console_be.c
