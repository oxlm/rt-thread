# Keil uVision project template.uvprojx, settings and files
target rt-thread (6220000::V6.22::ARMCLANG)
  device: NS800RT7P65D-DHQFOY2 Novosense
  pack: NOVOSENSE.NS800RT7XXX.0.5.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x00080000) IROM2(0x08080000,0x00080000) XRAM(0x20100000,0x00020000) XRAM2(0x20120000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8080000 size 0x80000
  memory RVCT6: ROM 0x20100000 size 0x20000
  memory RVCT7: ROM 0x20120000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
